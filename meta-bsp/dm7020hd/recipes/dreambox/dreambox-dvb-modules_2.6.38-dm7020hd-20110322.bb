require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.1"

SRC_URI[modules.md5sum] = "f3e0f778b279103254f5615a9f91acef"
SRC_URI[modules.sha256sum] = "c59dd9d996ee9d427bc9293dc121b07d788c3df0afb5414cc373619e612b4ec7"
