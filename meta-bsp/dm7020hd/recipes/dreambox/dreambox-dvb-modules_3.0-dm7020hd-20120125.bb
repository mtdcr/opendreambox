require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "d1e534d45b51ee64a76452bac84b951e"
SRC_URI[modules.sha256sum] = "4a19a57621f4dac18c89427c8ea39511131401f1de17dba5ff9e5e43732a42a7"
