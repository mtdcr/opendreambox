require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "de4c9fb720092d65f9741a67697ee5a3"
SRC_URI[second-bin.sha256sum] = "a1e275c5cdc4be0142d73b8e8c247fda86a46665e71d38dc21cf49e832f36f65"
SRC_URI[second-nfi.md5sum] = "5049616a4664ebe918b98ad4f6249cfd"
SRC_URI[second-nfi.sha256sum] = "467e4fff584921707dd0bd61205f9b507106d1d6768d3ade8b25b77614e39406"
