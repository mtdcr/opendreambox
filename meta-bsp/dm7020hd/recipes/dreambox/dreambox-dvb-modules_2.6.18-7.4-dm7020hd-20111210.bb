require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "16a1946a6ad4420669c5ffac9613b40c"
SRC_URI[modules.sha256sum] = "15cfdf051878a198ecffbe64e2b331518fd979c77a7a6cbcd21a0327252ca517"
