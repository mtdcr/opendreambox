require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "184b58035eb88897251daca52245ad85"
SRC_URI[modules.sha256sum] = "4c0d2c349fb38e4f92b9359925bd6f32d854038845ba1e873aa035179c7449ed"
