require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "3b6971a52bdb4524e06deec58610c50f"
SRC_URI[modules.sha256sum] = "5b3f8ed5a5bc5d9f558b72c60aa0d47a2c4011bce1f8dca801b0a6cca30c69c8"
