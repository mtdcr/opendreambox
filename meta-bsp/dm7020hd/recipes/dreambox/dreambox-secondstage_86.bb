require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "51d43de794388a0fc07a6b4a3392d6d6"
SRC_URI[second-bin.sha256sum] = "203bc73ee14a71f7b94229185e34886eece566d5a6aa6540b1cf434bbcb61d84"
SRC_URI[second-nfi.md5sum] = "722e6f8775d90bb22f30ac3e350e0211"
SRC_URI[second-nfi.sha256sum] = "ae8dcaab35bd2e2d8fb07b351e3962a78a8ee3734fc1b58502545d526ec02ba1"
