SRC_URI[dm7020hd.md5sum] = "13a5fc67270f1de909d5881dfff77a00"
SRC_URI[dm7020hd.sha256sum] = "087f8a3bb720a6c0ab599da198225a6889cda84b10b7936768980735133bfb50"
