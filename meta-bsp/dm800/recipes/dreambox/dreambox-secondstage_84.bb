require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "365df746869b1bd3738c705068c6d16c"
SRC_URI[second-bin.sha256sum] = "5cddff85d70918805554f72049b105c8d64988ec79815119b5d962f52c17cb32"
SRC_URI[second-nfi.md5sum] = "1a62221ba4e6b1c4bb1ab042f9c2eb55"
SRC_URI[second-nfi.sha256sum] = "d2850a711347709217ecb9487ae7c82759b5e69b60e77701d88cd69e161776db"
