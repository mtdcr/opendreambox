require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "5110a38fab0d9177b6bc0904b0bb64a6"
SRC_URI[modules.sha256sum] = "618e63833a32646979655d9e86b3d13aa8983f542e72ac636332b702517873f1"
