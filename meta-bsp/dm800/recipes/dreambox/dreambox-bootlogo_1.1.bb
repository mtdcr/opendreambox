require recipes/dreambox/dreambox-bootlogo.inc

PR = "${INC_PR}.0"

SRC_URI[dm800.md5sum] = "c9315d7c513a14316ac1a36009ed03b4"
SRC_URI[dm800.sha256sum] = "8f4c1b65f7961090e2b9eba2020fafb5b43712038dd193b5b340965524eda895"
