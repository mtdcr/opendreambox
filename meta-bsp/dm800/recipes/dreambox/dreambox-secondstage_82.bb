require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "3f156922a52a4a29ce195ae144b4ca22"
SRC_URI[second-bin.sha256sum] = "e1ecbe7f8127ebbce357dab858380ed9908b4e239c1562c02eb04ca6293577b3"
SRC_URI[second-nfi.md5sum] = "64d0e5c5d90188c8f767d6bdf3f3b0dd"
SRC_URI[second-nfi.sha256sum] = "40b0e3e8673066162f924af1b34c8c54c453264deba186aab45b94747e5a6851"
