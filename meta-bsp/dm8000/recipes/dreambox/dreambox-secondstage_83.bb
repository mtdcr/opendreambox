require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "9a2877cf1cf6dd317c5f86800e7ad53f"
SRC_URI[second-bin.sha256sum] = "66c6dc6fe5fa965dd7b49a4fc0049d74701955114c312db11a12aa9c3dde7198"
SRC_URI[second-nfi.md5sum] = "e121b96311910c4d3822012bd65596dc"
SRC_URI[second-nfi.sha256sum] = "e18b19e32549c15999848ca218ec689bc479c118b30ae3b979cf2204b2e7ce47"
