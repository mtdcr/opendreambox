SRC_URI[dm8000.md5sum] = "c147af8e421c0f764a6ce3177b3641ab"
SRC_URI[dm8000.sha256sum] = "de9fd7b0fc8da25f389b28f615fd877a5d1361ff5d993530d8940842cfb6469f"
