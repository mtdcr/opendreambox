require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "a51f2f6fed2f14cdd664dbd1f6c5c9df"
SRC_URI[modules.sha256sum] = "48e9b846cc835691571fdc606b3aeb13100c5fa842c1896db8ca807de581e9fa"
