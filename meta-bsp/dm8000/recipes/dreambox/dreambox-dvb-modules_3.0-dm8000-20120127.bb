require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "d446d93561f11c746bec8492cd7cf515"
SRC_URI[modules.sha256sum] = "3e0787ec3b7bb99097c48e9530555f6b6efd6c0c98d7df14158a73b5ade9822a"
