require dreambox-dvb-modules-dm8000.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "823a5296eefb91eb208bc3edf43c58cc"
SRC_URI[modules.sha256sum] = "af97bf22f73c7a12777921f81fec7735c2d88bc74d82f17d7fa986ac5ff150e2"
