require dreambox-dvb-modules-dm8000.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "e266227337b274466894620d7e2cd2f4"
SRC_URI[modules.sha256sum] = "b6af02640f5bc70a7f9c59d00fd57fa386d7e4d0794112e69e725cda1b68c79e"
