require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "d7880cd3fb2f2d2e05147e029bd7e71b"
SRC_URI[modules.sha256sum] = "fe4f9ab94ef6c3d9c16c09d95e8b0efbd4df2ceba228fb946402b172a3971a6e"
