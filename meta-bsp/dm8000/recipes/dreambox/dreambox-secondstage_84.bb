require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "8a6d83a266f88ec8fa5d130083f46d25"
SRC_URI[second-bin.sha256sum] = "b5dbfe00674e8dea38b5069b1bfde3fe6b4486d4c4556ac775b3127e8454ca98"
SRC_URI[second-nfi.md5sum] = "0234754870b3eb923b5961b6738d8ec0"
SRC_URI[second-nfi.sha256sum] = "3a7ad0b8eb796cc67926702dc747a58c3158078f102a80f8c63edb7b977e7a01"
