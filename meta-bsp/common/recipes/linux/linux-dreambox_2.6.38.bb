PR = "${INC_PR}.5"

SRCREV = "c941bae7b9cf78ab7a6ccca5d9553bc5646ebadb"

require linux-dreambox-git.inc
