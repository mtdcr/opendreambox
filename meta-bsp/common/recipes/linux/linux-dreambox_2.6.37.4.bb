PR = "${INC_PR}.2"

SRCREV = "06aa7c177b926ec3c55b369589094ef02e9ebf80"

require linux-dreambox-git.inc

BRANCH = "stblinux-${PV}-dream-stable"
