require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "166166a014eac838706589d7da471d5a"
SRC_URI[second-bin.sha256sum] = "92dd1a6375a3bca94b7264851d8cb114fc5794eee93eab104e10be44f0a7a621"
SRC_URI[second-nfi.md5sum] = "c7ae93591d9da26317e919a660a0a036"
SRC_URI[second-nfi.sha256sum] = "dffed373ae5cead1941e295368ea9b5d3592934bb86f905869d580306bf2aac1"
