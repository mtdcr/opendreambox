SRC_URI[dm800se.md5sum] = "29f63bd7c670f744bbb12eb25ad3234e"
SRC_URI[dm800se.sha256sum] = "97e015b45a9c1290650366141ca927d291bd456f76e2f84a2b8966e64e17917f"
