require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "3c335e3d1da39b4275ea2489f218f39b"
SRC_URI[second-bin.sha256sum] = "a378b1eb56780c0a0d19d9380d359b41556983508da05c4a1617f3c6cf702bd2"
SRC_URI[second-nfi.md5sum] = "134873f6071a3efddee7ec942bd3a9b8"
SRC_URI[second-nfi.sha256sum] = "35fb12a2464f78a7c95e509744bd66d63bf1e84501d7a9469db36fd51445a56a"
