require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "df43e0d715062e83124b435d778ed155"
SRC_URI[second-bin.sha256sum] = "c8490a2c4a645784b58b6693d6e274ef376db301670126ca952b9da7eef0c5c3"
SRC_URI[second-nfi.md5sum] = "29224516d8486d195f678f22647a85db"
SRC_URI[second-nfi.sha256sum] = "e352d8e4c7ad44caea2c41b37bf6e62e68e5cd70ab080485cef607587dc32ae7"
