require recipes/dreambox/dreambox-dvb-modules.inc

PR = "${INC_PR}.0"

SRC_URI[modules.md5sum] = "9543ad775879fb1f2cc35c68efc9a2c6"
SRC_URI[modules.sha256sum] = "276c43bf46db99e05a98a6326e285e3c0e8ded21b23fc867c1e9ecff2564af7b"
