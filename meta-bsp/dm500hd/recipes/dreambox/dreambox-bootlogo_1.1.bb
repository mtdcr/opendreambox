require recipes/dreambox/dreambox-bootlogo.inc

PR = "${INC_PR}.0"

SRC_URI[dm500hd.md5sum] = "5290901fa8b678d1a2bc90726f06b62d"
SRC_URI[dm500hd.sha256sum] = "5de22248fed0583b107de8724f35bc84d5e97e165a659122e050ab3981c40ad5"
