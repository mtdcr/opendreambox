require recipes/dreambox/dreambox-secondstage.inc

PR = "${INC_PR}.0"

SRC_URI[second-bin.md5sum] = "d13c2713f4062a7de53f02f6ae8dba48"
SRC_URI[second-bin.sha256sum] = "4280e588f85689fca109aeeabd54a98e22674ce0f98fb10c23878d72de54a227"
SRC_URI[second-nfi.md5sum] = "6b43dcffad913c6c5d56d05f27ddfcdf"
SRC_URI[second-nfi.sha256sum] = "6feacb711f2c60bc8bbc93a4b8be3663a8231d6fbadb9197395246fce5d0a23c"
