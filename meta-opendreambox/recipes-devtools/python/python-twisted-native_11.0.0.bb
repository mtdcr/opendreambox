require python-twisted_${PV}.bb

RDEPENDS_${PN} = ""

inherit native

SRC_URI[md5sum] = "d7f94a1609a1b8f3b8c8d0146d4cfe54"
SRC_URI[sha256sum] = "dd91254a4c946f51c4248590ca31b496ad3e4fd1b5a9fbc3a82c39a41131a2e2"
