PV = "0.3.91"

SRCREV = "eea752ae149c9c43d1b8cc2d7429f81168f7eaca"

inherit qt4e

require qxmpp-git.inc
