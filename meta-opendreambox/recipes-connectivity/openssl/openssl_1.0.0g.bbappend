PR .= "-dream1"

EXTRA_OECONF += "no-idea no-mdc2 no-rc5"
