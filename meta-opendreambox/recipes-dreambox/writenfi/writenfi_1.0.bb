DESCRIPTION = "copies NAND files to flash"
LICENSE = "GPL"
LIC_FILES_CHKSUM = "file://src/writenfi.c;endline=15;md5=48b89f10cba9a76a10efd3f9c2349d33"

SRCREV = "ef2bdee1641812e0ba246c4c1e0ca2ad559dc0f6"

inherit autotools opendreambox-git
