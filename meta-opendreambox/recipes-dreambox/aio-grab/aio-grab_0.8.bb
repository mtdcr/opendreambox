DESCRIPTION = "Screen grabber for Dreambox Set-Top-Boxes"
LICENSE = "GPLv2"

SRCREV = "${AUTOREV}"

inherit autotools pkgconfig schwerkraft-git
