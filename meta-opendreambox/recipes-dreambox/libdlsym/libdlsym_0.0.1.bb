DESCRIPTION = "Helper library to link against preloadable libraries"
SECTION = "base"
LICENSE = "CLOSED"
SRCREV = "${AUTOREV}"
PR = "r0"

inherit autotools opendreambox-git lib_package pkgconfig
