DESCRIPTION = "Displays an IFrame using a LinuxTV video decoder"
SECTION = "base"
LICENSE = "GPLv2"

SRCREV = "f19e4b573ba755ca6300df72b0736e98c967aba5"

inherit autotools opendreambox-git
