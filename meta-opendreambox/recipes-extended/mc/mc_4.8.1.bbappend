FILESEXTRAPATHS_prepend := "${THISDIR}/${P}:"

PR .= "-dream1"

RDEPENDS_${PN} = ""
